# Keil uVision project TEMPLATE.uvprojx, settings and files
target TEMPLATE (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\0_CORE;..\..\1_FWLIB_3_5_0\inc;..\..\3_PROJECT;..\..\6_uCOS-III\uC_CPU;..\..\6_uCOS-III\uC_LIB;..\..\6_uCOS-III\UCOS_III;..\..\6_uCOS-III\UCOS_CONFIG;..\..\6_uCOS-III\UCOS_III\Source;..\..\6_uCOS-III\uC_CPU\ARM-Cortex-M3\RealView;..\..\6_uCOS-III\uC_LIB\Ports\ARM-Cortex-M3\RealView;..\..\6_uCOS-III\UCOS_III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\6_uCOS-III\UCOS_BSP;..\..\2_DRIVE\Common;..\..\2_DRIVE\Common\DELAY;..\..\2_DRIVE\USART;..\..\2_DRIVE\OneWire;..\..\4_SENSORS;..\..\2_DRIVE\LED;..\..\2_DRIVE\KEY;..\..\4_SENSORS\ILI9225_LCDDrive;..\..\2_DRIVE\ADC;..\..\5_MODBUS\include;..\..\5_MODBUS\port;..\..\2_DRIVE\CAN
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../../0_CORE/: core_cm3.c
    ../../0_CORE/startup/: startup_stm32f10x_md.s
  group USER
    ../: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB_3_5_0
    ../../1_FWLIB_3_5_0/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group DRIVE
    ../../2_DRIVE/Common/DELAY/: delay.c
    ../../2_DRIVE/USART/: usart.c
    ../../2_DRIVE/OneWire/: OneWire.c
    ../../2_DRIVE/LED/: led.c
    ../../2_DRIVE/KEY/: key.c
    ../../2_DRIVE/ADC/: ADC.c
    ../../2_DRIVE/CAN/: CAN.c
  group Sensors
    ../../4_SENSORS/: DHTxx.c HCSR04.c PHOTORES.c TCS3200.c
  group LCD
    ../../4_SENSORS/ILI9225_LCDDrive/: GUI.c ILI9225_LCDDrive.c
  group MODBUS
    ../../5_MODBUS/sources/: mb.c mbascii.c mbcrc.c mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbrtu.c mbtcp.c mbutils.c
  group MODBUS_PORT
    ../../5_MODBUS/port/: portevent.c portserial.c porttimer.c port.c ModbusProtocol.c
  group UCOSIII_BSP
    ../../6_uCOS-III/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../../6_uCOS-III/uC_CPU/: cpu_core.c
    ../../6_uCOS-III/uC_CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../../6_uCOS-III/uC_LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../6_uCOS-III/uC_LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../../6_uCOS-III/UCOS_III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../../6_uCOS-III/UCOS_III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII_CONFIG
    ../../6_uCOS-III/UCOS_CONFIG/: os_app_hooks.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.h os_cfg.h os_cfg_app.h
